#include "display/latin2.h"

namespace Latin2 {

namespace {

const uint16_t UPPER[96] = {
    0x00A0, 0x0104, 0x02D8, 0x0141, 0x00A4, 0x013D, 0x015A, 0x00A7, 0x00A8, 0x0160, 0x015E, 0x0164,
    0x0179, 0x00AD, 0x017D, 0x017B, 0x00B0, 0x0105, 0x02DB, 0x0142, 0x00B4, 0x013E, 0x015B, 0x02C7,
    0x00B8, 0x0161, 0x015F, 0x0165, 0x017A, 0x02DD, 0x017E, 0x017C, 0x0154, 0x00C1, 0x00C2, 0x0102,
    0x00C4, 0x0139, 0x0106, 0x00C7, 0x010C, 0x00C9, 0x0118, 0x00CB, 0x011A, 0x00CD, 0x00CE, 0x010E,
    0x0110, 0x0143, 0x0147, 0x00D3, 0x00D4, 0x0150, 0x00D6, 0x00D7, 0x0158, 0x016E, 0x00DA, 0x0170,
    0x00DC, 0x00DD, 0x0162, 0x00DF, 0x0155, 0x00E1, 0x00E2, 0x0103, 0x00E4, 0x013A, 0x0107, 0x00E7,
    0x010D, 0x00E9, 0x0119, 0x00EB, 0x011B, 0x00ED, 0x00EE, 0x010F, 0x0111, 0x0144, 0x0148, 0x00F3,
    0x00F4, 0x0151, 0x00F6, 0x00F7, 0x0159, 0x016F, 0x00FA, 0x0171, 0x00FC, 0x00FD, 0x0163, 0x02D9,
};

struct Fallback {
  uint16_t cp;
  const char* text;
};

const Fallback FALLBACKS[] = {
    {0x2013, "-"}, {0x2014, "-"}, {0x2018, "'"}, {0x2019, "'"}, {0x201A, "'"}, {0x201C, "'"}, {0x201D, "'"},
    {0x201E, "'"}, {0x2026, "..."}, {0x00B7, "."}, {0x2022, "."}, {0x00E0, "a"}, {0x00E8, "e"}, {0x00EC, "i"},
    {0x00F2, "o"}, {0x00F9, "u"}, {0x00F1, "n"}, {0x00EA, "e"}, {0x00E5, "a"}, {0x00F8, "o"}, {0x00C0, "A"},
    {0x00C8, "E"}, {0x00D1, "N"}, {0x00C5, "A"}, {0x00D8, "O"}, {0x00E6, "ae"}, {0x00C6, "AE"},
};

String encode(uint32_t cp) {
  if (cp == '"') return "'";
  if (cp == '\\') return "/";
  if (cp == '\r' || cp == '\n' || cp == '\t') return " ";
  if (cp < 0x20) return "";
  if (cp < 0x80) return String(static_cast<char>(cp));
  for (uint8_t i = 0; i < 96; i++) {
    if (UPPER[i] == cp) return String(static_cast<char>(0xA0 + i));
  }
  for (const Fallback& f : FALLBACKS) {
    if (f.cp == cp) return f.text;
  }
  return "?";
}

}

String fromUtf8(const String& text, size_t maxLen) {
  String out;
  const uint8_t* p = reinterpret_cast<const uint8_t*>(text.c_str());
  while (*p && out.length() < maxLen) {
    uint32_t cp;
    if (*p < 0x80) {
      cp = *p++;
    } else if ((*p & 0xE0) == 0xC0 && (p[1] & 0xC0) == 0x80) {
      cp = ((p[0] & 0x1F) << 6) | (p[1] & 0x3F);
      p += 2;
    } else if ((*p & 0xF0) == 0xE0 && (p[1] & 0xC0) == 0x80 && (p[2] & 0xC0) == 0x80) {
      cp = ((p[0] & 0x0F) << 12) | ((p[1] & 0x3F) << 6) | (p[2] & 0x3F);
      p += 3;
    } else {
      p++;
      while ((*p & 0xC0) == 0x80) p++;
      cp = '?';
    }
    String part = encode(cp);
    if (out.length() + part.length() > maxLen) break;
    out += part;
  }
  return out;
}

}
